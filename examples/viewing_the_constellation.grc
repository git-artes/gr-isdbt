options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: viewing_the_constellation
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: Center freq.
    type: int
    value: '569143000'
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/16
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.4e6*80/63
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: active_carriers
  states: {}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    file: /home/flarroca/facultad/proyectos/2021_gr-isdbt/569MHz_recording/569MHz_recording.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: active_carriers
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(active_carriers)
  states: {}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.0625'
    interpolate: 'True'
    mode: '3'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5.6e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@1
    size: 2*active_carriers
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Incoming spectrum"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: tab@2
    label1: ''
    name: '"Channel gain (frequency, disregard the x-axis label)"'
    size: active_carriers
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: tab@2
    label1: ''
    label2: ''
    name: '"Channel taps"'
    size: active_carriers
    srate: samp_rate*active_carriers/total_carriers
    type: complex
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum
    label1: Constellation
    label2: Estimated channel
    num_tabs: '3'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_file_source_1_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_2, '0', qtgui_const_sink_x_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [isdbt_ofdm_synchronization_0, '0', blocks_vector_to_stream_0_2, '0']
- [isdbt_ofdm_synchronization_0, '1', blocks_complex_to_mag_0, '0']
- [isdbt_ofdm_synchronization_0, '1', fft_vxx_0_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
