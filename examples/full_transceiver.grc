<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>full_transceiver_isdbt</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>active_carriers</value></param>
<param><key>value</key><value>13*108*2**(mode-1)+1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const_size</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_carriers</value></param>
<param><key>value</key><value>13*96*2**(mode-1)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>epsilon</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Sampling Error</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1-1e-4</value></param>
<param><key>step</key><value>1e-6</value></param>
<param><key>stop</key><value>1+1e-4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_error</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Frequency Error</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>guard</value></param>
<param><key>value</key><value>1.0/16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_a</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_b</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_c</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mode</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>1e-9</value></param>
<param><key>label</key><value>Channel noise</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e-9</value></param>
<param><key>step</key><value>1e-6</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8e6*64/63</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>segments_a</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>segments_b</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>segments_c</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>total_carriers</value></param>
<param><key>value</key><value>2**(10+mode)</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>result_layer_b.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>result_layer_a.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>layer_a.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>layer_b.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>384</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>comment</key><value>See sec. 3.9.2 of the standard.</value></param>
<param><key>num_items</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>data_carriers</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>active_carriers</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512*4</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512*4</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>epsilon</value></param>
<param><key>freq_offset</key><value>freq_error</value></param>
<param><key>noise_voltage</key><value>noise</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>int(total_carriers*guard)</value></param>
<param><key>input_size</key><value>total_carriers</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0_0</value></param>
<param><key>code_rate</key><value>C2_3</value></param>
<param><key>constellation</key><value>qpsk</value></param>
<param><key>hierarchy</key><value>alpha4</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512*4</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0_0_0</value></param>
<param><key>code_rate</key><value>C3_4</value></param>
<param><key>constellation</key><value>64qam</value></param>
<param><key>hierarchy</key><value>alpha4</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512*4</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0_0</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>total_carriers</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(total_carriers)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>isdbt_bit_deinterleaver</key>
<param><key>id</key><value>isdbt_bit_deinterleaver_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>segments</key><value>segments_b</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_bit_deinterleaver</key>
<param><key>id</key><value>isdbt_bit_deinterleaver_0_0</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>segments</key><value>segments_a</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_byte_deinterleaver</key>
<param><key>id</key><value>isdbt_byte_deinterleaver_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_byte_deinterleaver</key>
<param><key>id</key><value>isdbt_byte_deinterleaver_0_0</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>nsegments</key><value>segments_a</value></param>
<param><key>rate</key><value>1</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>nsegments</key><value>segments_b</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_carrier_modulation</key>
<param><key>id</key><value>isdbt_carrier_modulation_0</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>segments</key><value>segments_a</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_carrier_modulation</key>
<param><key>id</key><value>isdbt_carrier_modulation_0_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>segments</key><value>segments_b</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_energy_descrambler</key>
<param><key>id</key><value>isdbt_energy_descrambler_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_energy_descrambler</key>
<param><key>id</key><value>isdbt_energy_descrambler_0_0</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_0</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>nsegments</key><value>segments_a</value></param>
<param><key>rate</key><value>1</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_0_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>nsegments</key><value>segments_b</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_frequency_deinterleaver</key>
<param><key>id</key><value>isdbt_frequency_deinterleaver_0</value></param>
<param><key>oneseg</key><value>True</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_frequency_interleaver</key>
<param><key>id</key><value>isdbt_frequency_interleaver_0</value></param>
<param><key>oneseg</key><value>True</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_hierarchical_combinator</key>
<param><key>id</key><value>isdbt_hierarchical_combinator_0</value></param>
<param><key>segments_A</key><value>segments_a</value></param>
<param><key>segments_B</key><value>segments_b</value></param>
<param><key>segments_C</key><value>0</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_ofdm_synchronization</key>
<param><key>id</key><value>isdbt_ofdm_synchronization_0</value></param>
<param><key>cp_length</key><value>0.0625</value></param>
<param><key>interpolate</key><value>True</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_pilot_signals</key>
<param><key>id</key><value>isdbt_pilot_signals_0</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_reed_solomon_dec_isdbt</key>
<param><key>id</key><value>isdbt_reed_solomon_dec_isdbt_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_reed_solomon_dec_isdbt</key>
<param><key>id</key><value>isdbt_reed_solomon_dec_isdbt_0_0</value></param>
</block>
<block>
<key>isdbt_symbol_demapper</key>
<param><key>id</key><value>isdbt_symbol_demapper_0</value></param>
<param><key>constellation_size_A</key><value>4</value></param>
<param><key>segments_A</key><value>segments_a</value></param>
<param><key>constellation_size_B</key><value>64</value></param>
<param><key>segments_B</key><value>segments_b</value></param>
<param><key>constellation_size_C</key><value>64</value></param>
<param><key>segments_C</key><value>segments_c</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_time_deinterleaver</key>
<param><key>id</key><value>isdbt_time_deinterleaver_0</value></param>
<param><key>length_A</key><value>length_a</value></param>
<param><key>segments_A</key><value>segments_a</value></param>
<param><key>length_B</key><value>length_b</value></param>
<param><key>segments_B</key><value>segments_b</value></param>
<param><key>length_C</key><value>length_c</value></param>
<param><key>segments_C</key><value>segments_c</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_time_interleaver</key>
<param><key>id</key><value>isdbt_time_interleaver_0</value></param>
<param><key>length_A</key><value>length_a</value></param>
<param><key>segments_A</key><value>segments_a</value></param>
<param><key>length_B</key><value>length_b</value></param>
<param><key>segments_B</key><value>segments_b</value></param>
<param><key>length_C</key><value>length_c</value></param>
<param><key>segments_C</key><value>segments_c</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_tmcc_decoder</key>
<param><key>id</key><value>isdbt_tmcc_decoder_0</value></param>
<param><key>print_params</key><value>False</value></param>
<param><key>transmission_mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_tmcc_encoder</key>
<param><key>id</key><value>isdbt_tmcc_encoder_0</value></param>
<param><key>int_length_A</key><value>length_a</value></param>
<param><key>mod_scheme_A</key><value>4</value></param>
<param><key>conv_code_A</key><value>1</value></param>
<param><key>nsegs_A</key><value>segments_a</value></param>
<param><key>int_length_B</key><value>length_b</value></param>
<param><key>mod_scheme_B</key><value>64</value></param>
<param><key>conv_code_B</key><value>2</value></param>
<param><key>nsegs_B</key><value>segments_b</value></param>
<param><key>int_length_C</key><value>0</value></param>
<param><key>mod_scheme_C</key><value>4</value></param>
<param><key>conv_code_C</key><value>0</value></param>
<param><key>nsegs_C</key><value>0</value></param>
<param><key>one_seg_present</key><value>True</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_viterbi_decoder</key>
<param><key>id</key><value>isdbt_viterbi_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>rate</key><value>2</value></param>
</block>
<block>
<key>isdbt_viterbi_decoder</key>
<param><key>id</key><value>isdbt_viterbi_decoder_0_0</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>rate</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>5.8e6/2.0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>0.5e6</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"reed-solomon"</value></param>
<param><key>size</key><value>total_carriers</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-9</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"viterbi"</value></param>
<param><key>size</key><value>total_carriers*24</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-9</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>isdbt_pilot_signals_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>isdbt_carrier_modulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0</source_block_id><sink_block_id>isdbt_carrier_modulation_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0</source_block_id><sink_block_id>isdbt_energy_dispersal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0_0</source_block_id><sink_block_id>isdbt_energy_dispersal_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_bit_deinterleaver_0</source_block_id><sink_block_id>isdbt_viterbi_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_bit_deinterleaver_0_0</source_block_id><sink_block_id>isdbt_viterbi_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0</source_block_id><sink_block_id>isdbt_energy_descrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0_0</source_block_id><sink_block_id>isdbt_energy_descrambler_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0_0</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_carrier_modulation_0</source_block_id><sink_block_id>isdbt_hierarchical_combinator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_carrier_modulation_0_0</source_block_id><sink_block_id>isdbt_hierarchical_combinator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0</source_block_id><sink_block_id>isdbt_reed_solomon_dec_isdbt_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0_0</source_block_id><sink_block_id>isdbt_reed_solomon_dec_isdbt_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_0</source_block_id><sink_block_id>isdbt_byte_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_0_0</source_block_id><sink_block_id>isdbt_byte_interleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frequency_deinterleaver_0</source_block_id><sink_block_id>isdbt_time_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frequency_interleaver_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_combinator_0</source_block_id><sink_block_id>isdbt_time_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_synchronization_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_synchronization_0</source_block_id><sink_block_id>isdbt_tmcc_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_pilot_signals_0</source_block_id><sink_block_id>isdbt_tmcc_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_bit_deinterleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_bit_deinterleaver_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_deinterleaver_0</source_block_id><sink_block_id>isdbt_symbol_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_interleaver_0</source_block_id><sink_block_id>isdbt_frequency_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_decoder_0</source_block_id><sink_block_id>isdbt_frequency_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_encoder_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0</source_block_id><sink_block_id>isdbt_byte_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0_0</source_block_id><sink_block_id>isdbt_byte_deinterleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>isdbt_ofdm_synchronization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
