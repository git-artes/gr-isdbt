options:
  parameters:
    author: flarroca
    generate_options: qt_gui
    id: tests
    output_language: python
    title: tests of gr-isdbt
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Actual sampling rate (% samp_rate)
    orient: Qt.Horizontal
    start: 1-1e-4
    step: '1e-6'
    stop: 1+1e-4
    value: '1'
  states: {}
- name: freq_error
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Frequency error (% samp_rate)
    orient: Qt.Horizontal
    start: '-0.05'
    step: '1e-5'
    stop: '0.05'
    value: '0'
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1/16.0
  states: {}
- name: length_a
  id: variable
  parameters:
    value: '4'
  states: {}
- name: length_b
  id: variable
  parameters:
    value: '2'
  states: {}
- name: length_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    label: Channel noise
    orient: Qt.Horizontal
    start: '1e-9'
    step: '1e-2'
    stop: '10'
    value: '1e-9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*64/63
  states: {}
- name: segments_a
  id: variable
  parameters:
    value: '1'
  states: {}
- name: segments_b
  id: variable
  parameters:
    value: '12'
  states: {}
- name: segments_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '256'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '256'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/flarroca/salida_b.ts
    type: byte
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/flarroca/salida_a.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/flarroca/facultad/gnuradio/layer_a.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/flarroca/facultad/gnuradio/layer_b.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_uchar_1
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: '188'
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: '384'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: See sec. 3.9.2 of the standard.
    num_items: '2'
    type: complex
    vlen: data_carriers
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: 13*96*2**(3-1)
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {state: disabled}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: 1512*4
    type: byte
  states: {}
- name: blocks_vector_to_stream_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: 1512*4
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: epsilon
    freq_offset: freq_error
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: int(total_carriers*guard)
    input_size: total_carriers
    tagname: ''
  states: {}
- name: dtv_dvbt_inner_coder_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C2_3
    constellation: qpsk
    hierarchy: alpha4
    ninput: '1'
    noutput: 1512*4
  states: {}
- name: dtv_dvbt_inner_coder_0_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C3_4
    constellation: 64qam
    hierarchy: alpha4
    ninput: '1'
    noutput: 1512*4
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: total_carriers
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(total_carriers)
  states: {}
- name: isdbt_bit_deinterleaver_0_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '64'
    mode: '3'
    segments: segments_b
  states: {}
- name: isdbt_bit_deinterleaver_0_0_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '4'
    mode: '3'
    segments: segments_a
  states: {state: disabled}
- name: isdbt_byte_deinterleaver_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {}
- name: isdbt_byte_deinterleaver_0_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {state: disabled}
- name: isdbt_byte_interleaver_0
  id: isdbt_byte_interleaver
  parameters:
    constellation_size: '4'
    mode: '3'
    nsegments: segments_a
    rate: '1'
  states: {}
- name: isdbt_byte_interleaver_0_0
  id: isdbt_byte_interleaver
  parameters:
    constellation_size: '64'
    mode: '3'
    nsegments: segments_b
    rate: '2'
  states: {}
- name: isdbt_carrier_modulation_0
  id: isdbt_carrier_modulation
  parameters:
    constellation_size: '4'
    mode: '3'
    segments: segments_a
  states: {}
- name: isdbt_carrier_modulation_0_0
  id: isdbt_carrier_modulation
  parameters:
    constellation_size: '64'
    mode: '3'
    segments: segments_b
  states: {}
- name: isdbt_energy_descrambler_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {}
- name: isdbt_energy_descrambler_0_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {state: disabled}
- name: isdbt_energy_dispersal_0
  id: isdbt_energy_dispersal
  parameters:
    constellation_size: '4'
    mode: '3'
    nsegments: segments_a
    rate: '1'
  states: {}
- name: isdbt_energy_dispersal_0_0
  id: isdbt_energy_dispersal
  parameters:
    constellation_size: '64'
    mode: '3'
    nsegments: segments_b
    rate: '2'
  states: {}
- name: isdbt_frequency_deinterleaver_0
  id: isdbt_frequency_deinterleaver
  parameters:
    mode: '3'
    oneseg: 'True'
  states: {}
- name: isdbt_frequency_interleaver_0
  id: isdbt_frequency_interleaver
  parameters:
    mode: '3'
    oneseg: 'True'
  states: {}
- name: isdbt_hierarchical_combinator_0
  id: isdbt_hierarchical_combinator
  parameters:
    mode: '3'
    segments_A: segments_a
    segments_B: segments_b
    segments_C: segments_c
  states: {}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.0625'
    interpolate: 'False'
    mode: '3'
  states: {}
- name: isdbt_pilot_signals_0
  id: isdbt_pilot_signals
  parameters:
    mode: '3'
  states: {}
- name: isdbt_reed_solomon_dec_isdbt_0
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {}
- name: isdbt_reed_solomon_dec_isdbt_0_0
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {state: disabled}
- name: isdbt_symbol_demapper_0
  id: isdbt_symbol_demapper
  parameters:
    constellation_size_A: '4'
    constellation_size_B: '64'
    constellation_size_C: '4'
    mode: '3'
    segments_A: segments_a
    segments_B: segments_b
    segments_C: segments_c
  states: {}
- name: isdbt_time_deinterleaver_0
  id: isdbt_time_deinterleaver
  parameters:
    length_A: length_a
    length_B: length_b
    length_C: length_c
    mode: '3'
    segments_A: segments_a
    segments_B: segments_b
    segments_C: segments_c
  states: {}
- name: isdbt_time_interleaver_0
  id: isdbt_time_interleaver
  parameters:
    length_A: length_a
    length_B: length_b
    length_C: length_c
    mode: '3'
    segments_A: segments_a
    segments_B: segments_b
    segments_C: segments_c
  states: {}
- name: isdbt_tmcc_decoder_0
  id: isdbt_tmcc_decoder
  parameters:
    mode: '3'
    print_params: 'False'
  states: {}
- name: isdbt_tmcc_encoder_0
  id: isdbt_tmcc_encoder
  parameters:
    conv_code_A: '1'
    conv_code_B: '2'
    conv_code_C: '0'
    int_length_A: length_a
    int_length_B: length_b
    int_length_C: length_c
    mod_scheme_A: '4'
    mod_scheme_B: '64'
    mod_scheme_C: '4'
    mode: '3'
    nsegs_A: segments_a
    nsegs_B: segments_b
    nsegs_C: segments_c
    one_seg_present: 'True'
  states: {}
- name: isdbt_viterbi_decoder_0_0
  id: isdbt_viterbi_decoder
  parameters:
    constellation_size: '64'
    rate: '2'
  states: {}
- name: isdbt_viterbi_decoder_0_0_0
  id: isdbt_viterbi_decoder
  parameters:
    constellation_size: '4'
    rate: '1'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-10'
    name: '"BER pre-Viterbi (log10)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-35'
    name: '"BER post-Viterbi (log10)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-35'
    name: '"BER post-Viterbi (log10)"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-10'
    name: '"BER pre-Viterbi (log10)"'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_float_to_uchar_1, '0']
- [analog_noise_source_x_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_float_to_uchar_1, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_nlog10_ff_0_0_0_1, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_nlog10_ff_0_0_1, '0', qtgui_number_sink_0_1, '0']
- [blocks_skiphead_0, '0', isdbt_pilot_signals_0, '0']
- [blocks_stream_to_vector_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [blocks_stream_to_vector_0_0, '0', dtv_dvbt_reed_solomon_enc_0_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_1_1, '0', blocks_file_sink_0_1, '0']
- [blocks_vector_to_stream_2, '0', isdbt_carrier_modulation_0, '0']
- [blocks_vector_to_stream_2_0, '0', isdbt_carrier_modulation_0_0, '0']
- [channels_channel_model_0, '0', low_pass_filter_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_throttle_0, '0']
- [dtv_dvbt_inner_coder_0, '0', blocks_vector_to_stream_2, '0']
- [dtv_dvbt_inner_coder_0_0, '0', blocks_vector_to_stream_2_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', isdbt_energy_dispersal_0, '0']
- [dtv_dvbt_reed_solomon_enc_0_0, '0', isdbt_energy_dispersal_0_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [isdbt_bit_deinterleaver_0_0, '0', isdbt_viterbi_decoder_0_0, '0']
- [isdbt_bit_deinterleaver_0_0_0, '0', isdbt_viterbi_decoder_0_0_0, '0']
- [isdbt_byte_deinterleaver_0, '0', isdbt_energy_descrambler_0, '0']
- [isdbt_byte_deinterleaver_0_0, '0', isdbt_energy_descrambler_0_0, '0']
- [isdbt_byte_interleaver_0, '0', dtv_dvbt_inner_coder_0, '0']
- [isdbt_byte_interleaver_0_0, '0', dtv_dvbt_inner_coder_0_0, '0']
- [isdbt_carrier_modulation_0, '0', isdbt_hierarchical_combinator_0, '0']
- [isdbt_carrier_modulation_0_0, '0', isdbt_hierarchical_combinator_0, '1']
- [isdbt_energy_descrambler_0, '0', isdbt_reed_solomon_dec_isdbt_0, '0']
- [isdbt_energy_descrambler_0_0, '0', isdbt_reed_solomon_dec_isdbt_0_0, '0']
- [isdbt_energy_dispersal_0, '0', isdbt_byte_interleaver_0, '0']
- [isdbt_energy_dispersal_0_0, '0', isdbt_byte_interleaver_0_0, '0']
- [isdbt_frequency_deinterleaver_0, '0', isdbt_time_deinterleaver_0, '0']
- [isdbt_frequency_interleaver_0, '0', blocks_skiphead_0, '0']
- [isdbt_hierarchical_combinator_0, '0', isdbt_time_interleaver_0, '0']
- [isdbt_ofdm_synchronization_0, '0', isdbt_tmcc_decoder_0, '0']
- [isdbt_pilot_signals_0, '0', isdbt_tmcc_encoder_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0, '0', blocks_null_sink_0_0_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0, '0', blocks_vector_to_stream_1, '0']
- [isdbt_reed_solomon_dec_isdbt_0, '1', blocks_nlog10_ff_0_0_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0_0, '0', blocks_vector_to_stream_1_1, '0']
- [isdbt_reed_solomon_dec_isdbt_0_0, '1', blocks_nlog10_ff_0_0_0_1, '0']
- [isdbt_symbol_demapper_0, '0', blocks_null_sink_0_0_1, '0']
- [isdbt_symbol_demapper_0, '0', isdbt_bit_deinterleaver_0_0_0, '0']
- [isdbt_symbol_demapper_0, '1', isdbt_bit_deinterleaver_0_0, '0']
- [isdbt_time_deinterleaver_0, '0', blocks_vector_to_stream_0, '0']
- [isdbt_time_deinterleaver_0, '0', isdbt_symbol_demapper_0, '0']
- [isdbt_time_interleaver_0, '0', isdbt_frequency_interleaver_0, '0']
- [isdbt_tmcc_decoder_0, '0', isdbt_frequency_deinterleaver_0, '0']
- [isdbt_tmcc_encoder_0, '0', fft_vxx_0, '0']
- [isdbt_viterbi_decoder_0_0, '0', isdbt_byte_deinterleaver_0, '0']
- [isdbt_viterbi_decoder_0_0, '1', single_pole_iir_filter_xx_0, '0']
- [isdbt_viterbi_decoder_0_0_0, '0', isdbt_byte_deinterleaver_0_0, '0']
- [isdbt_viterbi_decoder_0_0_0, '1', single_pole_iir_filter_xx_0_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_nlog10_ff_0_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_nlog10_ff_0_0_1, '0']

metadata:
  file_format: 1
